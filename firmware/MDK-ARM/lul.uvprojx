# Keil uVision project lul.uvprojx, settings and files
target lul (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F072C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: lul +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072xB
  c misc: --C99
  c include: ../Inc;                                             ../Drivers/STM32F0xx_HAL_Driver/Inc;                                             ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;                                             ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;                                             ../Drivers/CMSIS/Include;                                          ../Middlewares/Third_Party/FatFs/src;                            ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                            ../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Inc;                ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0;                ../Middlewares/Third_Party/FreeRTOS/Source/include;                ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Application/User
    ../Src/: stm32f0xx_it.c main.c stm32f0xx_hal_msp.c user_diskio.c fatfs.c sd_util.c fonts.c ssd1306.c neopixel.c buttons.c usb_device.c usbd_conf.c usbd_desc.c keyboard.c parser.c freertos.c stm32f0xx_hal_timebase_TIM.c my_tasks.c animations.c
    ../Inc/: shared.h sd_util.h ssd1306.h fonts.h neopixel.h buttons.h keyboard.h parser.h my_tasks.h animations.h
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_tim.c stm32f0xx_hal_uart.c stm32f0xx_hal.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_flash.c stm32f0xx_hal_cortex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_iwdg.c
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff.c diskio.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c timers.c list.c tasks.c queue.c croutine.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_1.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
software components: CMSIS:CORE 4.1.0
